# Keil uVision project rt1064.uvprojx, settings and files
target nor_sdram_zf_dtcm (6240000::V6.24::ARMCLANG)
  device: MIMXRT1064DVL6A NXP
  pack: NXP.MIMXRT1064_DFP.25.12.00
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x00000000,0x020000) IROM(0x70000000,0x400000) XRAM(0x20200000,0x0c0000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: rt1064
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: CPU_MIMXRT1064DVL6A,SKIP_SYSCLK_INIT,XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_DCD_ENABLE =1, XIP_BOOT_HEADER_ENABLE =1,PRINTF_FLOAT_ENABLE=1, SCANF_FLOAT_ENABLE=1, PRINTF_ADVANCED_ENABLE=1, SCANF_ADVANCED_ENABLE=1, FSL_DRIVER_TRANSFER_DOUBLE_WEAK_IRQ=0, USB_STACK_BM, DEBUG, MCUXPRESSO_SDK, SD_ENABLED
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb -Wno-invalid-source-encoding
  c include: ..\app;..\code;..\..\libraries\sdk\startup\mdk;..\..\libraries\sdk\deceive;..\..\libraries\sdk\drives;..\..\libraries\sdk\xip;..\..\libraries\sdk\utilities;..\..\libraries\sdk\utilities\debug_console;..\..\libraries\sdk\utilities\str;..\..\libraries\sdk\cmsis_drivers;..\..\libraries\sdk\CMSIS\Include;..\..\libraries\sdk\CMSIS\Driver\Include;..\..\libraries\sdk\components\lists;..\..\libraries\sdk\components\osa;..\..\libraries\sdk\components\serial_manager;..\..\libraries\sdk\components\uart;..\..\libraries\sdk\board;..\..\libraries\components\fatfs\source;..\..\libraries\components\fatfs\source\fsl_sd_disk;..\..\libraries\components\sdmmc;..\..\libraries\components\sdmmc\common;..\..\libraries\components\sdmmc\host\usdhc;..\..\libraries\components\sdmmc\osa;..\..\libraries\components\sdmmc\sd;..\..\libraries\components\usb\device;..\..\libraries\components\usb\include;..\..\libraries\components\usb\phy;..\..\libraries\components\usb\usb_cdc_adapter;..\..\libraries\zf_common;..\..\libraries\zf_driver;..\..\libraries\zf_device;..\..\libraries\zf_components;..\code\lvgl;..\gui;..\gui\custom;..\gui\generated;..\gui\generated\guider_customer_fonts;..\gui\generated\guider_fonts;..\gui\generated\images
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT4: ROM 0x70000000 size 0x400000
  memory RVCT6: RAM 0x20200000 size 0xc0000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: .\scf\MIMXRT1064xxxxx_flexspi_nor.scf
  link misc: --remove --entry=Reset_Handler
  group app
    ../app/: main.c isr.c isr.h board_init.c board_init.h board_input.c board_input.h protocol.c protocol.h
  group lv_config
    ../code/: lv_conf.h lv_conf_ext.h
  group lvgl
    ..//code//lvgl//src//core//: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ..//code//lvgl//src//draw//arm2d//: lv_gpu_arm2d.c
    ..//code//lvgl//src//draw//: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ..//code//lvgl//src//draw//nxp//pxp//: lv_draw_pxp.c lv_draw_pxp_blend.c lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp_osa.c
    ..//code//lvgl//src//draw//nxp//vglite//: lv_draw_vglite.c lv_draw_vglite_arc.c lv_draw_vglite_blend.c lv_draw_vglite_line.c lv_draw_vglite_rect.c lv_vglite_buf.c lv_vglite_utils.c
    ..//code//lvgl//src//draw//renesas//: lv_gpu_d2_draw_label.c lv_gpu_d2_ra6m3.c
    ..//code//lvgl//src//draw//sdl//: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_layer.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c
    ..//code//lvgl//src//draw//stm32_dma2d//: lv_gpu_stm32_dma2d.c
    ..//code//lvgl//src//draw//sw//: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    ..//code//lvgl//src//draw//swm341_dma2d//: lv_gpu_swm341_dma2d.c
    ..//code//lvgl//src//extra//layouts//flex//: lv_flex.c
    ..//code//lvgl//src//extra//layouts//grid//: lv_grid.c
    ..//code//lvgl//src//extra//libs//barcode//: code128.c lv_barcode.c
    ..//code//lvgl//src//extra//libs//bmp//: lv_bmp.c
    ..//code//lvgl//src//extra//libs//ffmpeg//: lv_ffmpeg.c
    ..//code//lvgl//src//extra//libs//freetype//: lv_freetype.c
    ..//code//lvgl//src//extra//libs//fsdrv//: lv_fs_fatfs.c lv_fs_posix.c lv_fs_rawfs.c lv_fs_stdio.c lv_fs_win32.c
    ..//code//lvgl//src//extra//libs//gif//: gifdec.c lv_gif.c
    ..//code//lvgl//src//extra//libs//png//: lodepng.c lv_png.c
    ..//code//lvgl//src//extra//libs//qrcode//: lv_qrcode.c qrcodegen.c
    ..//code//lvgl//src//extra//libs//rlottie//: lv_rlottie.c
    ..//code//lvgl//src//extra//libs//sjpg//: lv_sjpg.c tjpgd.c
    ..//code//lvgl//src//extra//: lv_extra.c
    ..//code//lvgl//src//extra//others//fragment//: lv_fragment.c lv_fragment_manager.c
    ..//code//lvgl//src//extra//others//gridnav//: lv_gridnav.c
    ..//code//lvgl//src//extra//others//ime//: lv_ime_pinyin.c
    ..//code//lvgl//src//extra//others//imgfont//: lv_imgfont.c
    ..//code//lvgl//src//extra//others//monkey//: lv_monkey.c
    ..//code//lvgl//src//extra//others//msg//: lv_msg.c
    ..//code//lvgl//src//extra//others//snapshot//: lv_snapshot.c
    ..//code//lvgl//src//extra//themes//basic//: lv_theme_basic.c
    ..//code//lvgl//src//extra//themes//default//: lv_theme_default.c
    ..//code//lvgl//src//extra//themes//mono//: lv_theme_mono.c
    ..//code//lvgl//src//extra//widgets//analogclock//: lv_analogclock.c
    ..//code//lvgl//src//extra//widgets//animimg//: lv_animimg.c
    ..//code//lvgl//src//extra//widgets//calendar//: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ..//code//lvgl//src//extra//widgets//carousel//: lv_carousel.c
    ..//code//lvgl//src//extra//widgets//chart//: lv_chart.c
    ..//code//lvgl//src//extra//widgets//colorwheel//: lv_colorwheel.c
    ..//code//lvgl//src//extra//widgets//dclock//: lv_dclock.c
    ..//code//lvgl//src//extra//widgets//imgbtn//: lv_imgbtn.c
    ..//code//lvgl//src//extra//widgets//keyboard//: lv_keyboard.c lv_zh_keyboard.c
    ..//code//lvgl//src//extra//widgets//led//: lv_led.c
    ..//code//lvgl//src//extra//widgets//list//: lv_list.c
    ..//code//lvgl//src//extra//widgets//menu//: lv_menu.c
    ..//code//lvgl//src//extra//widgets//meter//: lv_meter.c
    ..//code//lvgl//src//extra//widgets//msgbox//: lv_msgbox.c
    ..//code//lvgl//src//extra//widgets//radiobtn//: lv_radiobtn.c
    ..//code//lvgl//src//extra//widgets//span//: lv_span.c
    ..//code//lvgl//src//extra//widgets//spinbox//: lv_spinbox.c
    ..//code//lvgl//src//extra//widgets//spinner//: lv_spinner.c
    ..//code//lvgl//src//extra//widgets//tabview//: lv_tabview.c
    ..//code//lvgl//src//extra//widgets//textprogress//: lv_textprogress.c
    ..//code//lvgl//src//extra//widgets//tileview//: lv_tileview.c
    ..//code//lvgl//src//extra//widgets//video//: lv_video.c
    ..//code//lvgl//src//extra//widgets//win//: lv_win.c
    ..//code//lvgl//src//font//: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_simsun_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c
    ..//code//lvgl//src//hal//: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ..//code//lvgl//src//misc//: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ..//code//lvgl//src//widgets//: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group gui/custom
    ../gui/custom/: custom.c ui_user_events.c
  group gui/generated
    ../gui/generated/: gui_guider.c events_init.c setup_scr_lockscreen.c setup_scr_menu.c setup_scr_joystick_mode.c widgets_init.c
    ../gui/generated/images/: _back_alpha_240x320.c
    ../gui/generated/guider_fonts/: lv_font_ALMM_16.c lv_font_ALMM_23.c lv_font_ALMM_32.c lv_font_ALMM_48.c
  group doc
    ../../libraries/doc/: GPL3_permission_statement.txt read me.txt version.txt
  group zf_common
    ../../libraries/zf_common/: zf_common_clock.c zf_common_clock.h zf_common_debug.c zf_common_debug.h zf_common_fifo.c zf_common_fifo.h zf_common_font.c zf_common_font.h zf_common_function.c zf_common_function.h zf_common_headfile.h zf_common_interrupt.c zf_common_interrupt.h zf_common_typedef.h zf_common_vector.c zf_common_vector.h
  group zf_driver
    ../../libraries/zf_driver/: zf_driver_adc.c zf_driver_adc.h zf_driver_csi.c zf_driver_csi.h zf_driver_delay.c zf_driver_delay.h zf_driver_encoder.c zf_driver_encoder.h zf_driver_exti.c zf_driver_exti.h zf_driver_flash.c zf_driver_flash.h zf_driver_flexio_csi.c zf_driver_flexio_csi.h zf_driver_gpio.c zf_driver_gpio.h zf_driver_iic.c zf_driver_iic.h zf_driver_pit.c zf_driver_pit.h zf_driver_pwm.c zf_driver_pwm.h zf_driver_romapi.c zf_driver_romapi.h zf_driver_sdio.c zf_driver_sdio.h zf_driver_soft_iic.c zf_driver_soft_iic.h zf_driver_soft_spi.c zf_driver_soft_spi.h zf_driver_spi.c zf_driver_spi.h zf_driver_timer.c zf_driver_timer.h zf_driver_uart.c zf_driver_uart.h zf_driver_usb_cdc.c zf_driver_usb_cdc.h
  group zf_device
    ../../libraries/zf_device/: zf_device_absolute_encoder.c zf_device_absolute_encoder.h zf_device_bluetooth_ch9141.c zf_device_bluetooth_ch9141.h zf_device_camera.c zf_device_camera.h zf_device_icm20602.c zf_device_icm20602.h zf_device_imu963ra.c zf_device_imu963ra.h zf_device_imu660ra.c zf_device_imu660ra.h zf_device_imu660rb.c zf_device_imu660rb.h zf_device_imu660rc.c zf_device_imu660rc.h zf_device_ips114.c zf_device_ips114.h zf_device_ips200.c zf_device_ips200.h zf_device_key.c zf_device_key.h zf_device_mpu6050.c zf_device_mpu6050.h zf_device_mt9v03x.c zf_device_mt9v03x.h zf_device_mt9v03x_flexio.c zf_device_mt9v03x_flexio.h zf_device_oled.c zf_device_oled.h zf_device_ov7725.c zf_device_ov7725.h zf_device_scc8660.c zf_device_scc8660.h zf_device_scc8660_flexio.c zf_device_scc8660_flexio.h zf_device_tft180.c zf_device_tft180.h zf_device_tsl1401.c zf_device_tsl1401.h zf_device_type.c zf_device_type.h zf_device_virtual_oscilloscope.c zf_device_virtual_oscilloscope.h zf_device_wifi_uart.c zf_device_wifi_uart.h zf_device_wireless_uart.c zf_device_wireless_uart.h zf_device_config.h zf_device_config.lib zf_device_dl1a.c zf_device_dl1a.h zf_device_dl1b.c zf_device_dl1b.h zf_device_wifi_spi.c zf_device_wifi_spi.h zf_device_gnss.c zf_device_gnss.h zf_device_ble6a20.c zf_device_ble6a20.h zf_device_ips200pro.c zf_device_ips200pro.h
  group zf_components
    ../../libraries/zf_components/: seekfree_assistant.c seekfree_assistant.h seekfree_assistant_interface.c seekfree_assistant_interface.h
  group sdk_drivers
    ../../libraries/sdk/drives/: fsl_adc.c fsl_adc.h fsl_adc_etc.c fsl_adc_etc.h fsl_aipstz.c fsl_aipstz.h fsl_aoi.c fsl_aoi.h fsl_bee.c fsl_bee.h fsl_cache.c fsl_cache.h fsl_clock.c fsl_clock.h fsl_cmp.c fsl_cmp.h fsl_common.c fsl_common.h fsl_common_arm.c fsl_common_arm.h fsl_csi.c fsl_csi.h fsl_dcdc.c fsl_dcdc.h fsl_dcp.c fsl_dcp.h fsl_dmamux.c fsl_dmamux.h fsl_edma.c fsl_edma.h fsl_elcdif.c fsl_elcdif.h fsl_enc.c fsl_enc.h fsl_enet.c fsl_enet.h fsl_ewm.c fsl_ewm.h fsl_flexcan.c fsl_flexcan.h fsl_flexcan_edma.c fsl_flexcan_edma.h fsl_flexio.c fsl_flexio.h fsl_flexio_camera.c fsl_flexio_camera.h fsl_flexio_camera_edma.c fsl_flexio_camera_edma.h fsl_flexio_i2c_master.c fsl_flexio_i2c_master.h fsl_flexio_i2s.c fsl_flexio_i2s.h fsl_flexio_i2s_edma.c fsl_flexio_i2s_edma.h fsl_flexio_mculcd.c fsl_flexio_mculcd.h fsl_flexio_mculcd_edma.c fsl_flexio_mculcd_edma.h fsl_flexio_spi.c fsl_flexio_spi.h fsl_flexio_spi_edma.c fsl_flexio_spi_edma.h fsl_flexio_uart.c fsl_flexio_uart.h fsl_flexio_uart_edma.c fsl_flexio_uart_edma.h fsl_flexram.c fsl_flexram.h fsl_flexram_allocate.c fsl_flexram_allocate.h fsl_flexspi.c fsl_flexspi.h fsl_gpc.c fsl_gpc.h fsl_gpio.c fsl_gpio.h fsl_gpt.c fsl_gpt.h fsl_iomuxc.h fsl_kpp.c fsl_kpp.h fsl_lpi2c.c fsl_lpi2c.h fsl_lpi2c_edma.c fsl_lpi2c_edma.h fsl_lpspi.c fsl_lpspi.h fsl_lpspi_edma.c fsl_lpspi_edma.h fsl_lpuart.c fsl_lpuart.h fsl_lpuart_edma.c fsl_lpuart_edma.h fsl_ocotp.c fsl_ocotp.h fsl_pit.c fsl_pit.h fsl_pmu.c fsl_pmu.h fsl_pwm.c fsl_pwm.h fsl_pxp.c fsl_pxp.h fsl_qtmr.c fsl_qtmr.h fsl_rtwdog.c fsl_rtwdog.h fsl_sai.c fsl_sai.h fsl_sai_edma.c fsl_sai_edma.h fsl_semc.c fsl_semc.h fsl_snvs_hp.c fsl_snvs_hp.h fsl_snvs_lp.c fsl_snvs_lp.h fsl_spdif.c fsl_spdif.h fsl_spdif_edma.c fsl_spdif_edma.h fsl_src.c fsl_src.h fsl_tempmon.c fsl_tempmon.h fsl_trng.c fsl_trng.h fsl_tsc.c fsl_tsc.h fsl_usdhc.c fsl_usdhc.h fsl_wdog.c fsl_wdog.h fsl_xbara.c fsl_xbara.h fsl_xbarb.c fsl_xbarb.h
  group sdk_device
    ../../libraries/sdk/board/: board.c board.h clock_config.c clock_config.h
    ../../libraries/sdk/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c evkmimxrt1064_sdram_ini_dcd.h evkmimxrt1064_sdram_ini_dcd.c evkmimxrt1064_flexspi_nor_config.h evkmimxrt1064_flexspi_nor_config.c
    ../../libraries/sdk/deceive/: system_MIMXRT1064.h system_MIMXRT1064.c MIMXRT1064_features.h MIMXRT1064.h fsl_device_registers.h
    ../../libraries/sdk/startup/mdk/: startup_MIMXRT1064.S
    ../../libraries/sdk/utilities/: fsl_assert.c
    ../../libraries/sdk/components/osa/: fsl_os_abstraction.h fsl_os_abstraction_bm.c fsl_os_abstraction_bm.h fsl_os_abstraction_config.h
    ../../libraries/sdk/components/lists/: fsl_component_generic_list.c
    ../../libraries/sdk/components/uart/: fsl_adapter_lpuart.c fsl_adapter_uart.h
    ../../libraries/sdk/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
  group components_fatfs
    ../../libraries/components/fatfs/source/: diskio.c diskio.h ff.c ff.h ffconf.h ffsystem.c ffunicode.c
    ../../libraries/components/fatfs/source/fsl_sd_disk/: fsl_sd_disk.c fsl_sd_disk.h
  group components_sdmmc
    ../../libraries/components/sdmmc/: sdmmc_config.c sdmmc_config.h
    ../../libraries/components/sdmmc/common/: fsl_sdmmc_common.c fsl_sdmmc_common.h fsl_sdmmc_spec.h
    ../../libraries/components/sdmmc/host/usdhc/: fsl_sdmmc_host.h
    ../../libraries/components/sdmmc/host/usdhc/non_blocking/: fsl_sdmmc_host.c
    ../../libraries/components/sdmmc/osa/: fsl_sdmmc_osa.c fsl_sdmmc_osa.h
    ../../libraries/components/sdmmc/sd/: fsl_sd.c fsl_sd.h
  group components_usb
    ../../libraries/components/usb/device/: usb_device_ehci.c usb_device_ehci.h usb_device_dci.c usb_device_dci.h usb_device.h
    ../../libraries/components/usb/include/: usb.h usb_misc.h usb_spec.h
    ../../libraries/components/usb/phy/: usb_phy.c usb_phy.h
    ../../libraries/components/usb/usb_cdc_adapter/: usb_device_cdc_acm.c usb_device_cdc_acm.h usb_device_ch9.c usb_device_ch9.h usb_device_class.c usb_device_class.h usb_device_config.h usb_device_descriptor.c usb_device_descriptor.h
